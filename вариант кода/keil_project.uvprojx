# Keil uVision project keil_project.uvprojx, settings and files
target Project (ARM-ADS)
  device: STM32F100C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: keil_project +hex
  AfterMake: fromelf --bin --output .\output\keil_project.bin .\output\keil_project.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\source;.\source\CMSIS;.\source\config;.\source\startup;.\source\std_periph_lib;.\source\STM32_init
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ./source/CMSIS/: core_cm3.c core_cm3.h system_stm32f10x.c system_stm32f10x.h
  group config
    ./source/config/: stm32f10x_conf.h stm32f10x.h
  group startup
    ./source/startup/: startup_stm32f10x_md_vl.s
  group std_periph_lib
    ./source/std_periph_lib/: misc.c misc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_rtc.c stm32f10x_rtc.h
  group source
    ./source/: main.c
software components: CMSIS:CORE 5.4.0
