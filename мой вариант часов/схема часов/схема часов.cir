.title KiCad schematic
BT1 Net-_BT1-Pad1_ GND Battery_Cell
Q1 Net-_D1-Pad3_ Net-_Q1-Pad2_ Net-_BT1-Pad1_ IRLML6402
Q3 Net-_D1-Pad3_ Net-_Q1-Pad2_ /напряжение генератора для индикатора /Vi IRLML6402
R2 Net-_BT1-Pad1_ Net-_D1-Pad3_ 200k
D1 +12C GND Net-_D1-Pad3_ BAT54C
R3 Net-_D1-Pad3_ Net-_C1-Pad1_ 10k
D2 +12C GND /напряжение генератора для индикатора /Vi BAT54C
R4 /напряжение генератора для индикатора /Vi /входное напряжение/TYPE_V 10k
R5 /входное напряжение/TYPE_V GND 10k
C2 /входное напряжение/TYPE_V GND 100n
Q2 /MK/KEY_V_MK GND Net-_C1-Pad1_ BSS123
CB1 Net-_C1-Pad1_ GND CircuitBreaker_1P
C1 Net-_C1-Pad1_ GND 100n
R1 /MK/KEY_V_MK GND 10k
U1 /напряжение генератора для индикатора /Vi Net-_R6-Pad2_ /напряжение микроконтролерра/V_MK LM317_TO39
C3 /напряжение генератора для индикатора /Vi GND 0.1u
R6 /напряжение микроконтролерра/V_MK Net-_R6-Pad2_ 4k
R7 Net-_R6-Pad2_ GND 11k
C5 /напряжение микроконтролерра/V_MK GND 1u
C4 Net-_C4-Pad1_ GND 10u
D3 Net-_C4-Pad1_ /напряжение микроконтролерра/V_MK 1N4002
U2 /напряжение генератора для индикатора /Vi Net-_D4-Pad2_ Net-_C7-Pad1_ GND Net-_C8-Pad1_ /напряжение генератора для индикатора /Vi Net-_L1-Pad1_ /напряжение генератора для индикатора /Vi MC34063AP
C7 Net-_C7-Pad1_ GND 1n
C6 /напряжение генератора для индикатора /Vi GND 1000u
R8 /напряжение генератора для индикатора /Vi Net-_L1-Pad1_ 0.2
L1 Net-_L1-Pad1_ Net-_D5-Pad2_ 230
D4 Net-_D4-Pad1_ Net-_D4-Pad2_ 1N4148
Q4 Net-_D4-Pad1_ Net-_D4-Pad2_ Net-_Q4-Pad3_ 2N3906
Q5 Net-_D5-Pad2_ Net-_D4-Pad1_ Net-_Q4-Pad3_ IRF840
D5 /напряжение генератора для индикатора /V_indicators Net-_D5-Pad2_ 1N4007
R11 /напряжение генератора для индикатора /V_indicators Net-_R11-Pad2_ 430k
R9 Net-_C8-Pad1_ Net-_R11-Pad2_ 3k
C8 Net-_C8-Pad1_ GND 1n
R10 Net-_D4-Pad2_ Net-_Q4-Pad3_ 10k
U3 NC_01 NC_02 NC_03 NC_04 NC_05 NC_06 NC_07 NC_08 NC_09 /входное напряжение/TYPE_V NC_10 NC_11 NC_12 NC_13 NC_14 NC_15 NC_16 /MK/Y1 NC_17 /MK/Y3 /MK/Y2 /MK/Y0 NC_18 NC_19 NC_20 NC_21 NC_22 NC_23 NC_24 NC_25 NC_26 NC_27 NC_28 NC_29 NC_30 NC_31 NC_32 NC_33 /MK/Y4 /MK/Y5 /MK/X1 /MK/X2 /MK/X3 NC_34 /MK/X4 /MK/KEY_V_MK NC_35 NC_36 STM32F103C8Tx
D6 NC_37 /indicators/0 /indicators/9 /indicators/8 /indicators/7 /indicators/6 /indicators/5 /indicators/4 /indicators/3 /indicators/2 /indicators/1 NC_38 in-12a
D9 NC_39 NC_40 NC_41 NC_42 NC_43 NC_44 NC_45 NC_46 NC_47 NC_48 NC_49 NC_50 in-12a
D10 NC_51 NC_52 NC_53 NC_54 NC_55 NC_56 NC_57 NC_58 NC_59 NC_60 NC_61 NC_62 in-12a
D11 NC_63 NC_64 NC_65 NC_66 NC_67 NC_68 NC_69 NC_70 NC_71 NC_72 NC_73 NC_74 in-12a
D12 NC_75 NC_76 NC_77 NC_78 NC_79 NC_80 NC_81 NC_82 NC_83 NC_84 NC_85 NC_86 in-12a
U4 /MK/Y0 Net-_R13-Pad1_ NC_87 Net-_R12-Pad1_ TLP627
U5 /MK/Y1 Net-_R13-Pad1_ NC_88 Net-_R12-Pad1_ TLP627
U6 /MK/Y2 Net-_R13-Pad1_ NC_89 Net-_R12-Pad1_ TLP627
U7 /MK/Y3 Net-_R13-Pad1_ NC_90 Net-_R12-Pad1_ TLP627
U8 /MK/Y4 Net-_R13-Pad1_ NC_91 Net-_R12-Pad1_ TLP627
U9 /MK/Y5 Net-_R13-Pad1_ NC_92 Net-_R12-Pad1_ TLP627
R12 Net-_R12-Pad1_ /напряжение генератора для индикатора /V_indicators 10k
R13 Net-_R13-Pad1_ GND 470
D7 /indicators/9 /indicators/0 /MK/X1 /MK/X4 /напряжение микроконтролерра/V_MK /MK/X2 /MK/X3 /indicators/3 /indicators/4 /indicators/8 /indicators/7 GND /indicators/5 /indicators/6 /indicators/2 /indicators/1 SN74141N
D8 NC_93 NC_94 NC_95 NC_96 NC_97 NC_98 NC_99 NC_100 NC_101 NC_102 NC_103 NC_104 in-12a
.end
