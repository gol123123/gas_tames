# Keil uVision project nixi.uvprojx, settings and files
target NIXI (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: nixi
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c define: __heap_base__=Image$$RW_IRAM1$$ZI$$Limit __heap_end__=Image$$RW_IRAM2$$Base
  c include: ..\..\..\os\kernel\include;..\..\..\os\ports\common\ARMCMx;..\..\..\os\ports\common\ARMCMx\CMSIS\include;..\..\..\os\ports\RVCT\ARMCMx;..\..\..\os\ports\RVCT\ARMCMx\STM32F1xx;..\..\..\os\hal\include;..\..\..\os\hal\platforms\STM32;..\..\..\os\hal\platforms\STM32\GPIOv1;..\..\..\os\hal\platforms\STM32\I2Cv1;..\..\..\os\hal\platforms\STM32\OTGv1;..\..\..\os\hal\platforms\STM32\RTCv1;..\..\..\os\hal\platforms\STM32\SPIv1;..\..\..\os\hal\platforms\STM32\TIMv1;..\..\..\os\hal\platforms\STM32\USARTv1;..\..\..\os\hal\platforms\STM32\USBv1;..\..\..\os\hal\platforms\STM32F1xx;..\src;..\src\board;..\..\..\os\various
  asm misc: --cpreproc
  asm include: ..\..\..\os\ports\common\ARMCMx;..\..\..\os\ports\common\ARMCMx\CMSIS\include;..\..\..\os\ports\RVCT\ARMCMx\STM32F1xx;..\src;..\src\board
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../src/: main.cpp chconf.h halconf.h mcuconf.h
    ../../../os/various/: chrtclib.h chrtclib.c
  group board
    ../src/board/: board.h board.c
  group port
    ../../../os/ports/common/ARMCMx/: nvic.c nvic.h
    ../../../os/ports/RVCT/ARMCMx/: chcore.h chcore.c chcore_v7m.c chcore_v7m.h chcoreasm_v7m.s chtypes.h cstartup.s
    ../../../os/ports/RVCT/ARMCMx/STM32F1xx/: cmparams.h vectors.s
  group kernel
    ../../../os/kernel/include/: ch.h chbsem.h chcond.h chdebug.h chdynamic.h chevents.h chfiles.h chheap.h chinline.h chlists.h chmboxes.h chmemcore.h chmempools.h chmsg.h chmtx.h chqueues.h chregistry.h chschd.h chsem.h chstreams.h chsys.h chthreads.h chvt.h
    ../../../os/kernel/src/: chcond.c chdebug.c chdynamic.c chevents.c chheap.c chlists.c chmboxes.c chmemcore.c chmempools.c chmsg.c chmtx.c chqueues.c chregistry.c chschd.c chsem.c chsys.c chthreads.c chvt.c
  group hal
    ../../../os/hal/include/: adc.h can.h ext.h gpt.h hal.h i2c.h icu.h io_block.h io_channel.h mac.h mii.h mmc_spi.h mmcsd.h pal.h pwm.h rtc.h sdc.h serial.h serial_usb.h spi.h tm.h uart.h usb.h
    ../../../os/hal/src/: adc.c can.c ext.c gpt.c hal.c i2c.c icu.c mac.c mmc_spi.c mmcsd.c pal.c pwm.c rtc.c sdc.c serial.c serial_usb.c spi.c tm.c uart.c usb.c
  group platform
    ../../../os/hal/platforms/STM32/: can_lld.h can_lld.c ext_lld.h ext_lld.c i2s_lld.h i2s_lld.c mac_lld.h mac_lld.c sdc_lld.h sdc_lld.c stm32.h
    ../../../os/hal/platforms/STM32/GPIOv1/: pal_lld.h pal_lld.c
    ../../../os/hal/platforms/STM32/I2Cv1/: i2c_lld.h i2c_lld.c
    ../../../os/hal/platforms/STM32/OTGv1/: usb_lld.h usb_lld.c stm32_otg.h
    ../../../os/hal/platforms/STM32/RTCv1/: rtc_lld.h rtc_lld.c
    ../../../os/hal/platforms/STM32/SPIv1/: spi_lld.h spi_lld.c
    ../../../os/hal/platforms/STM32/TIMv1/: gpt_lld.h gpt_lld.c icu_lld.h icu_lld.c pwm_lld.h pwm_lld.c stm32_tim.h
    ../../../os/hal/platforms/STM32/USARTv1/: serial_lld.h serial_lld.c uart_lld.h uart_lld.c
    ../../../os/hal/platforms/STM32/USBv1/: stm32_usb.h
    ../../../os/hal/platforms/STM32F1xx/: adc_lld.h adc_lld.c ext_lld_isr.h ext_lld_isr.c hal_lld.h hal_lld.c hal_lld_f103.h hal_lld_f100.h stm32_dma.c stm32_dma.h stm32_isr.h stm32_rcc.h stm32f10x.h hal_lld_f105_f107.h
  group LM75
    ../src/: tmp75.h tmp75.c i2c_pns.h i2c_pns.c
software components: CMSIS:CORE 5.4.0
